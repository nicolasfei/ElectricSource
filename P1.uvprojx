# Keil uVision project P1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: P1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\CMSIS\GD\GD32F4xx\Include;.\GD32F4xx_standard_peripheral\Include;.\Hardware;.\Modbus;.\OS;.\User;.\Algorithm;.\Control
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Peripheral
    ./GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Algorithm
    ./Algorithm/: UserTimer.lib Filter.lib
  group Hardware
    ./Hardware/: Pinout.c SysTick.c TM1640.c usart.c WatchDog.c spi.c PWM.c
  group OS
    ./OS/: TaskManage.c
  group Modbus
    ./Modbus/: ModbusSlave.c DataComm.c
  group Control
    ./Control/: CommIndicator.c DispParam.c ErrorControl.c GetAdc.c OutSwitch.c GetTemp.c Ds18b20.h Ds18b20.c
  group User
    ./User/: main.c
